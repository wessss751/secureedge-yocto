
SYSTEMD_AUTO_ENABLE:${PN}-mark-good = "disable"
